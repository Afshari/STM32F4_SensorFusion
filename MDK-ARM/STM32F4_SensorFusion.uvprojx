# Keil uVision project STM32F4_SensorFusion.uvprojx, settings and files
target STM32F4 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F429ZI_NUCLEO_144
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F4XX_NUCLEO_144
  c include: ../Inc;../Src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/BSP/STM32F4xx_Nucleo_144;../Drivers/BSP/Components/Common;../Middlewares/Third_Party/LwIP/src/include/;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Utilities;../Utilities/Log;..\Inc\Classes;..\Inc\Math
  asm include: ROJ_DIR$\..\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c list.c timers.c tasks.c
  group Middlewares/LwIP/Core
    ../Middlewares/Third_Party/LwIP/src/core/: mem.c netif.c memp.c init.c tcp_in.c def.c pbuf.c stats.c inet_chksum.c tcp.c tcp_out.c ip.c timeouts.c raw.c dns.c udp.c sys.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma2d.c
  group Middlewares/LwIP/Netif
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/LwIP/Api
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c sockets.c api_lib.c netdb.c err.c tcpip.c netbuf.c api_msg.c
  group Middlewares/FreeRTOS/portable
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/BSP/STM32F4xx_Nucleo_144
    ../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Middlewares/LwIP/Core/IPv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c igmp.c ip4_addr.c dhcp.c icmp.c autoip.c ip4_frag.c ip4.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/Config
    ../Src/: ethernetif.cpp app_ethernet.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c
  group Application/Main
    ../Src/: main.cpp tcp_server.cpp
  group Application/Classes
    ../Src/Classes/: input_parser.cpp network_data_handler.cpp app_handler.cpp recursive_least_squares.cpp kf_tracking.cpp kf_passive_suspension.cpp
  group Middlewares/Math
    ../Src/Math/: matrix.cpp
  group Application/Tests
    ../Src/Tests/: test_base.cpp tests_runner.cpp test_input_parser.cpp test_network_data_handler.cpp test_matrix.cpp test_recursive_least_squares.cpp test_kf_tracking.cpp test_kf_passive_suspension.cpp
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
